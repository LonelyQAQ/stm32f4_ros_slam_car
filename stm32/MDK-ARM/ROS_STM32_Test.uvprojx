# Keil uVision project ROS_STM32_Test.uvprojx, settings and files
target ROS_STM32_Test (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ROS_STM32_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx,RMW_UXRCE_TRANSPORT=custom
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\app;..\app\Device;..\app\Protocol;..\app\System;..\firmware\board;..\firmware\motor;..\firmware\encoder;..\firmware\bmi088;..\firmware\vqf
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group App
    ../app/: microros_app_includes.h
  group Device
    ../app/Device/: dev_imu.c dev_imu.h dev_uart.c dev_attitude.c dev_attitude.h dev_uart.h
  group Protocal
    ../app/Protocol/: uros_app.c uros_app.h uros_transport.c uros_transport.h uros_stub.c frame_link.c
  group System
    ../app/System/: app_cfg.h app_main.c app_main.h
  group Firmware
    ../firmware/motor/: motor.c
    ../firmware/encoder/: encoder.c
    ../firmware/bmi088/: bmi088.c
    ../firmware/vqf/: vqf.c
software components: CMSIS:CORE 6.1.1
